# Keil uVision project batsim.uvproj, settings and files
target T2662 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: batsim
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup
    ./: Startup.s
  group Config
    ./: swi_table.s RTX_CONFIG_batsim.C
  group Source
    ./: main.c serial.c dac8531.c ADS8321.c
  group USB
    ./: usbuser.c usbdesc.c usbhw.c usbcore.c cdcuser.c
